# Keil uVision project KEYPAD.uvprojx, settings and files
target KEYPAD (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lph9135 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Libs\CMSIS;.\Libs\Drivers\inc;.\Libs\Drivers\src;.\Libs\Startup;.\User;.\Libs\core;.\User\inc;.\User\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ./Libs/CMSIS/: system_stm32f30x.c stm32f30x.h
  group Startup
    ./Libs/Startup/: startup_stm32f303xc.s
  group Drivers
    ./Libs/Drivers/src/: stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_tim.c
  group Source
    ./User/src/: keyboard.c main.c timers.c
